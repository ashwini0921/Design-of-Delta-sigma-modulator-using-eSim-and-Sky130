* G:\delta\delta.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 12/28/22 23:46:41

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X2  Vdd Vss Net-_X1-Pad5_ GND delta_out GND avsd_opamp
v6  clk GND pulse
scmode1  SKY130mode
v1  Net-_v1-Pad1_ GND pulse
v2  Net-_v2-Pad1_ Net-_v1-Pad1_ pulse
v3  in Net-_v2-Pad1_ pulse
U1  in plot_v1
v7  Vdd GND DC
v8  GND Vss DC
v9  Vrin GND DC
X6  Vdd Vss Net-_SC12-Pad2_ GND delay_in GND avsd_opamp
SC12  Net-_SC12-Pad1_ Net-_SC12-Pad2_ Vrin sky130_fd_pr__res_generic_pd
SC15  Net-_SC12-Pad2_ delay_in Vrin sky130_fd_pr__res_generic_pd
SC13  Net-_SC12-Pad2_ Net-_SC13-Pad2_ Vrin sky130_fd_pr__res_generic_pd
SC9  Net-_SC12-Pad1_ Net-_SC10-Pad1_ Vrin sky130_fd_pr__res_generic_pd
SC14  Net-_SC13-Pad2_ dout1 Vrin sky130_fd_pr__res_generic_pd
SC10  Net-_SC10-Pad1_ dout2 Vrin sky130_fd_pr__res_generic_pd
SC8  Net-_SC7-Pad2_ Net-_SC12-Pad1_ Vrin sky130_fd_pr__res_generic_pd
SC7  GND Net-_SC7-Pad2_ Vrin sky130_fd_pr__res_generic_pd
X3  Vdd Vss Net-_SC5-Pad1_ in comp1 GND avsd_opamp
X4  Vdd Vss Net-_SC11-Pad2_ in comp2 GND avsd_opamp
X5  Vdd Vss Net-_SC11-Pad1_ in comp3 GND avsd_opamp
SC5  Net-_SC5-Pad1_ Net-_SC5-Pad2_ Vrin sky130_fd_pr__res_generic_pd
SC6  Net-_SC11-Pad2_ Net-_SC5-Pad1_ Vrin sky130_fd_pr__res_generic_pd
SC11  Net-_SC11-Pad1_ Net-_SC11-Pad2_ Vrin sky130_fd_pr__res_generic_pd
SC16  GND Net-_SC11-Pad1_ Vrin sky130_fd_pr__res_generic_pd
U3  clk comp1 comp2 comp3 GND Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ adc_bridge_5
v5  Net-_SC5-Pad2_ GND DC
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ ashwini_delay1bit
U4  Net-_U2-Pad6_ dout1 dac_bridge_1
U8  Net-_U2-Pad7_ dout2 dac_bridge_1
U7  delay_in plot_v1
U5  delta_out plot_v1
X1  Vdd Vss delay_in in Net-_X1-Pad5_ GND avsd_opamp

.end
